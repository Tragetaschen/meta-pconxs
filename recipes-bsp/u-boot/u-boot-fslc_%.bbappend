SRCBRANCH="pconxs-2014.07"
SRCREV = "AUTOINC"
SRC_URI = "git://github.com/Tragetaschen/u-boot-pconxs.git;protocol=http;branch=${SRCBRANCH}"
