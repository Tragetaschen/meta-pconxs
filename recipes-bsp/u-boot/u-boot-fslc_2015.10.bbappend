SRCBRANCH = "2015.10+target"
SRCREV = "AUTOINC"
SRC_URI = "git://github.com/Tragetaschen/u-boot-pconxs.git;protocol=http;branch=${SRCBRANCH}"
