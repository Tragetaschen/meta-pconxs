SRCBRANCH = "2016.03+target"
SRC_URI = "git://github.com/Tragetaschen/u-boot-pconxs.git;protocol=http;branch=${SRCBRANCH}"

