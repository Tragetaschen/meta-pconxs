SRCBRANCH = "trizeps7"
SRCREV = "AUTOINC"

require linux-stable.inc
